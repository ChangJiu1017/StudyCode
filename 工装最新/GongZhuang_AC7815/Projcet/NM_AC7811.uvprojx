# Keil uVision project NM_AC7811.uvprojx, settings and files
target NM_AC7811 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AC7815QBFE AutoChips
  pack: AutoChips.AC781x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NM_AC7811 +hex
  AfterMake: fromelf --m32combined --output=NM_AC7811.srec .\Objects\NM_AC7811.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\User;..\User\User_APP;..\User\Complex_Dri;..\User\ECU_Abs;..\User\MCU_Abs;..\User\Serve;..\User\User_APP;..\User\User_APP\1 BASIC;..\User\User_APP\2 MCU;..\User\User_APP\3 APPLICATION LOGIC;..\User\User_APP\3 APPLICATION LOGIC\INPUT;..\User\User_APP\3 APPLICATION LOGIC\MPI;..\User\User_APP\3 APPLICATION LOGIC\MPI\map;..\User\User_APP\3 APPLICATION LOGIC\MPI\map\map_for_vehicle;..\User\User_APP\3 APPLICATION LOGIC\MPI\map\map_for_vehicle\INJ_VERSION;..\User\User_APP\3 APPLICATION LOGIC\SCR;..\User\User_APP\4 CONSTITUTIVE LOGIC;..\User\User_APP\4 CONSTITUTIVE LOGIC\NOZZLE;..\User\User_APP\4 CONSTITUTIVE LOGIC\NOZZLE\map for injector;..\User\User_APP\5 PHAYSICAL LOGIC\MPI_H;..\User\User_APP\5 PHAYSICAL LOGIC;..\User\User_APP\5 PHAYSICAL LOGIC\MPI_C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\NM_AC7811.sct
  group MCU_Abs
    ../User/MCU_Abs/: main.c MCUabs_ADC.c MCUabs_ADC.h MCUabs_CAN.c MCUabs_CAN.h MCUabs_GPIO.c MCUabs_GPIO.h MCUabs_IIC.c MCUabs_IIC.h MCUabs_RTC.c MCUabs_RTC.h MCUabs_SCI.c MCUabs_SCI.h MCUabs_WGD.c MCUabs_WGD.h
  group ComPlex_Dri
    ../User/Complex_Dri/: Inj_Ing.c Inj_Ing.h
  group Serve
    ../User/Serve/: Service_CAN.c Service_CAN.h Service_IIC.c Service_IIC.h Service_SCI.c Service_SCI.h FAM.h
  group BASIC
    ../User/User_APP/1 BASIC/: data_sys_macro.h data_sys_standard.h Header.h public.h sys_definition.h
software components: CMSIS:CORE 5.0.1, Board Support:AC781x Development Kit:Debug Interface 1.0.0, Device:ATC Drivers:ACMP 1.0.0, Device:ATC Drivers:ADC 1.0.0, Device:ATC Drivers:CAN 1.0.0, Device:ATC Drivers:CRC 1.0.0, Device:ATC Drivers:CTU 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:I2C 1.0.0, Device:ATC Drivers:LIN 1.0.0, Device:ATC Drivers:PWDT 1.0.0, Device:ATC Drivers:PWM 1.0.0, Device:ATC Drivers:RTC 1.0.0, Device:ATC Drivers:SPI 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.0, Device:ATC Drivers:Watchdog 1.0.0, Device:ATC Drivers:eFlash 1.0.0, Device:ATC Drivers:sFlash 1.0.0, Device:Startup 1.0.0
